do_compile:append() {
    bbwarn "${PN} is depreciated and should not be used, it will be removed in the future"
}
