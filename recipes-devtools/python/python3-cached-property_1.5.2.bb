SUMMARY = "A decorator for caching properties in classes."
HOMEPAGE = "https://github.com/pydanny/cached-property"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=db7ff60c4e14f58534201242803d8abc"

inherit pypi setuptools3

SRC_URI[sha256sum] = "9fa5755838eecbb2d234c3aa390bd80fbd3ac6b6869109bfc1b499f7bd89a130"
