DESCRIPTION = "Python documentation generator"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=82cc7d23060a75a07b820eaaf75abecf"

PYPI_PACKAGE = "Sphinx"

SRC_URI[md5sum] = "80c5176104fe0cfbd1a8430b6da308b4"
SRC_URI[sha256sum] = "41cad293f954f7d37f803d97eb184158cfd90f51195131e94875bc07cd08b93c"
inherit setuptools3 pypi
