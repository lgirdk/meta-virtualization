inherit pypi setuptools3
DEPENDS += "${PYTHON_PN}-pip-native"
require python-docker.inc
