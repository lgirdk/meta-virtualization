inherit pypi setuptools
require python-docker-pycreds.inc

